# Keil uVision project STM32F103_Project.uvprojx, settings and files
target STM32F103_Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103_Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\User;.\Start;.\Library;.\System;.\Hardware
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group System
    ./System/: OLED.c OLED.h OLED_Font.h My_include.h MyGPIO.c MyGPIO.h SysBitBand.c SysBitBand.h usart.c usart.h myiic.c myiic.h sys.c sys.h delay.c delay.h Delay_1st.c Delay_1st.h My_include.c SG90Angle.c SG90Angle.h ExistTIM.c ExistTIM.h SG90PWM.c SG90PWM.h MySPI_W25.c MySPI_W25.h SPI_TFT.c SPI_TFT.h
  group Hardware
    ./Hardware/: Matrix_Key2.c Matrix_Key2.h FONT.H lcd.c lcd.h lcd_menu.c lcd_menu.h JR6001.c JR6001.h SG90Start_Zeroing.c SG90Start_Zeroing.h W25Q64.c W25Q64.h W25Q64_Ins.h W25_Store_password.c W25_Store_password.h Init_Refresh_unavailable.c Init_Refresh_unavailable.h W25_Data.c W25_Data.h Administrator.c Administrator.h ReturnCode_jdy31.c ReturnCode_jdy31.h serial_jdy31.c serial_jdy31.h
  group User
    ./User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h main.c GUI.c GUI.h test.c test.h my_image.h
  group Doc
    ./Doc/: readme.txt
